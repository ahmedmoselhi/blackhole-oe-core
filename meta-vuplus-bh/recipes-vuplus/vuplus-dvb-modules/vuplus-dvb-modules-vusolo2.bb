require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vusolo2)$"

SRCDATE = "20151201"

MODULES_NAME = "procmk\ndvb-bcm7356\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "5688d9ac8c3665c02bb08efebbda314b"
SRC_URI[sha256sum] = "fb0718de32cb20977d1498b936c1e38155a2b9a9df2cba1f1d69bdd40bb6dad1"
