require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuuno)$"

SRCDATE = "20151124"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "b303e8193079f70e347dfd439ed2e79d"
SRC_URI[sha256sum] = "d496fe3d965477aa33e51ef5bc201f8bbc4650931eadfb2f62c57ddac4b73fed"
