require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20151201"

MODULES_NAME = "procmk\ndvb-bcm7424\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "823dbddb0b9ce08c946a33e4a910b9f1"
SRC_URI[sha256sum] = "6234a4fefc2a461c38fb3e657102a01c6ae44ba311707704c3abc63e54e29638"
