require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vusolose)$"

SRCDATE = "20151201"

MODULES_NAME = "procmk\ndvb-bcm7241\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "8a0881b50eb7e188b09441c14b5357c4"
SRC_URI[sha256sum] = "46b6582d75bf13f58120dc136d25a96a3e477367ce3db7d083e3789f757793ad"
