require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuzero)$"

SRCDATE = "20151201"

MODULES_NAME = "procmk\ndvb-bcm7362\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "5d4d7057a1afe8cd65902e84a0d242fe"
SRC_URI[sha256sum] = "bcdc2a7a7b700de021f8501ed42b04bbba1b0c50b2ca9f54c5a3c57ed5201292"
