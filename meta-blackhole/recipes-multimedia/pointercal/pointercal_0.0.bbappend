PR_append = "-vuplus0"

BBCLASSEXTEND = "native"

