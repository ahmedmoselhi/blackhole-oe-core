require ${OPENPLI_BASE}/meta-openpli/recipes-openpli/images/openpli-enigma2-feed.bb

DEPENDS = "openblackhole-image"