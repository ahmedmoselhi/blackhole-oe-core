require openpli-enigma2-image.bb

IMAGE_INSTALL += " \
	mc \
	"

export IMAGE_BASENAME = "openblackhole"
